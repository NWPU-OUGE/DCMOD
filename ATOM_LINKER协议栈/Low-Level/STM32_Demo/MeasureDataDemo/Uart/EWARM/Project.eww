<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Atom_Protocol_STM32.ewp</path>
  </project>
  <batchBuild />
</workspace>
